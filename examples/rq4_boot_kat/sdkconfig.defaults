## examples/rq4_boot_kat/sdkconfig.defaults.r2
```kconfig
# R2: ESP-NN optimized kernels
CONFIG_ESP_TFLITE_MICRO_USE_ESP_NN=y
CONFIG_NN_OPTIMIZED=y
# CONFIG_NN_SKIP_NUDGE is not set
```
